Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2018-03-15T16:35:06
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160225_1515(x64) - Exporter 17.0.416.0 - Alternate UI 17.12.14.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Mar 15 16:35:06 2018 * Host: CHTSP10141 * Database: C:\Users\20062089\AppData\Local\Temp\{8FE42AF9-077E-4187-9DC9-C79AAB128081}\ifc * Database version: 5507 * Database creation date: Thu Mar 15 16:34:53 2018 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Mar 15 16:34:53 2018 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Mar 15 16:34:53 2018 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 30, 344238; RefLongitude: -71, -3, -35, -194702; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Identity Data - Type Name: 8mm Head; Building Story: yes; Name: Level 1; Structural: no
Graphics - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Constraints - Elevation Base: Project Base Point; Elevation: 0 mm
Dimensions - Computation Height: 0 mm

# IfcTransportElement: 1001212500_4045R, 1001212500_4045R:1001212500_4045R:551469
In: Level 1
Type - PredefinedType: ELEVATOR; Material: JLG_Paint_Black, JLG_Paint_White, JLG_Paint_Orange, JLG_Plastic_Red, JLG_Plastic_Yellow, JLG_Paint_Beige, JLG_Steel, JLG_Rubber_Light Grey, JLG_Plastic_Ligh tGrey, JLG_Paint_Grey
Type - Constraints - Height: -778 mm; Ht: 640 mm; Offset: 1418 mm; Platform_Height: 0 mm; Platform Extension: 0 mm; Platform Extension Maximum: User to define Extension; Platform Height Maximum: User to define Height; Platform Length: 2518 mm; PS: 2518 mm; PX: 0 mm; Static: 778 mm; Transportation Condition: no
Type - Data - Batteries: 48v DC (4 x 12v, 150 Ah); Drive: Hydraulic Front wheel; Drive Speed Elevator: 0.8 kph (0.5 mph); Drive Speed lowered: 3.2 kph (2.0 mph); Gradeability: 25%; Gross Vehicle Weight (ANSI): 3175 kg (7000 lbs); Gross Vehicle Weight (CE): 3175 kg (7000 lbs); Ground Clearance: 0.126 m (0 ft 5 in); Hydraulic Tank Capacity: 30 L (7.9 gal); Lift Up time: 68 sec; Lower down Time: 41 sec; Max Ground Bearing Pressure (ANSI): 9.63 kg/cm2 (137 psi); Max Ground Bearing Pressure (CE): 9.63 kg/cm2 (137 psi); Outside Turning Radius curb to curb: 2.33 m (7 ft 8 in); Outside Turning Radius wall to wall: 2.54 m (8 ft 4 in); Platform Capacity Indoor (ANSI): 350 kg (770 lbs); Platform Capacity Indoor (CE): 350 kg (770 lbs); Platform Extension Capacity (ANSI): 113 kg (250 lbs); Platform Extension Capacity (CE): 113 kg (250 lbs); Platform Extension Size ( L): 0.91 m (3 ft 0 in); Platform Height Indoor: 11.97 m (39 ft 3 in); Platform Size (W x L): 1.14 m x 2.52 m (3 ft 9 in x 8 ft 3 in); Tyres: 406 x 127 mm Non Marking Tyres
Type - General - Electric Scissor Lift: JLG_4045R; Platform Extension Size: 0.91 m (3 ft 0 in); Platform Size: 1.14 m x 2.52 m (3 ft 9 in x 8 ft 3 in)
Type - Identity Data - Manufacturer: JLG; OmniClass Number: 23.40.00.00; OmniClass Title: Equipment and Furnishings; Type Name: 1001212500_4045R; URL: https://www.jlg.com
Type - Model Properties - _Author: n/a; _AuthorizedBy: n/a; _BIMspec_GUID: n/a; _BimSpecGuid: n/a; _BSBibleVersion: n/a; _CreatedBy: JLG; _CurrentRevision: 0; _DistributedBy: JLG; BIMObjectName: 1001212500_4045R; NBSDescription: Electric Scissor Lift; NBSNote: n/a; NBSObjectName: JLG_4045R_Electric Scissor Lift; NBSOfficeMasterTag: n/a; NBSReference: n/a
Type - Other - Category: Mechanical Equipment; AccessibilityPerformance: n/a; AssetIdentifier (default): Please Record On Commissioning; AssetType: Elevators; BarCode (default): Please Record On Commissioning; ClassificationName: n/a; ClassificationValue: n/a; CodePerformance: n/a; Color: n/a; Constituents: n/a; CreatedBy: JLG (https://www.jlg.com/en); CreatedOn: 2018; DocumentationCertificates: n/a; DocumentationInstallationGuide: n/a; DocumentationLiterature: n/a; DocumentationMaintenance: n/a; DocumentationTechnical: n/a; DurationUnit: Years; ExpectedLife: n/a; Family Name: 1001212500_4045R; Features: n/a; Finish: n/a; Grade: n/a; InstallationDate (default): n/a; ManufacturerName: JLG (https://www.jlg.com/en); Material: n/a; ModelNumber: 4045R; ModelReference: JLG - Electric Scissor Lift; ProductionYear: n/a; ReferencedStandard: n/a; ReplacementCost: n/a; SerialNumber (default): Please Record On Commissioning; Shape: n/a; Size: n/a; SpareParts: n/a; TypeName: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Years; WarrantyGuarantorLabor: https://www.jlg.com; WarrantyGuarantorParts: https://www.jlg.com
OperationType: ELEVATOR; CapacityByWeight: 0 kg; CapacityByNumber: 0
Pset_ManufacturerTypeInformation - ModelReference: JLG - Electric Scissor Lift; Manufacturer: JLG; ProductionYear: n/a
Constraints - BWA: no; Extension Working Area: yes; Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 mm; Turning Radius: no; Working Area: no
Dimensions - Area: 105.479 m2; Volume: 1.05377 m3
Identity Data - Mark: 20
Other - Family: 1001212500_4045R: 1001212500_4045R; Family and Type: 1001212500_4045R: 1001212500_4045R; Type: 1001212500_4045R: 1001212500_4045R; Type Id: 1001212500_4045R: 1001212500_4045R; WarrantyStartDate (default): Please Record On Commissioning
Phasing - Phase Created: Phase 1
